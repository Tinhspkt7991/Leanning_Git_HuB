VAR.PRINT %STRING g_AES_Test_Result
