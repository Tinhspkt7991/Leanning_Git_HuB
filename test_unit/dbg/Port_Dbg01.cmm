Var.Print %STRING g_AES_Test_Result